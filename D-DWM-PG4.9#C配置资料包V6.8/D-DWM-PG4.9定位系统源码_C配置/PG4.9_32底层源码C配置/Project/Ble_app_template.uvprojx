# Keil uVision project Ble_app_template.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Ble_app_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192,ARM_MATH_CM4F CONFIG_NFCT_PINS_AS_GPIOS
  c include: ..\User;..\NRFLibraries\components;..\NRFLibraries\components\ble\ble_advertising;..\NRFLibraries\components\ble\ble_dtm;..\NRFLibraries\components\ble\ble_racp;..\NRFLibraries\components\ble\ble_link_ctx_manager;..\NRFLibraries\components\ble\ble_services\ble_ancs_c;..\NRFLibraries\components\ble\ble_services\ble_ans_c;..\NRFLibraries\components\ble\ble_services\ble_bas;..\NRFLibraries\components\ble\ble_services\ble_bas_c;..\NRFLibraries\components\ble\ble_services\ble_bps;..\NRFLibraries\components\ble\ble_services\ble_cscs;..\NRFLibraries\components\ble\ble_services\ble_cts_c;..\NRFLibraries\components\ble\ble_services\ble_dfu;..\NRFLibraries\components\ble\ble_services\ble_dis;..\NRFLibraries\components\ble\ble_services\ble_gls;..\NRFLibraries\components\ble\ble_services\ble_hids;..\NRFLibraries\components\ble\ble_services\ble_hrs;..\NRFLibraries\components\ble\ble_services\ble_hrs_c;..\NRFLibraries\components\ble\ble_services\ble_hts;..\NRFLibraries\components\ble\ble_services\ble_ias;..\NRFLibraries\components\ble\ble_services\ble_ias_c;..\NRFLibraries\components\ble\ble_services\ble_lbs;..\NRFLibraries\components\ble\ble_services\ble_lbs_c;..\NRFLibraries\components\ble\ble_services\ble_lls;..\NRFLibraries\components\ble\ble_services\ble_nus;..\NRFLibraries\components\ble\ble_services\ble_nus_c;..\NRFLibraries\components\ble\ble_services\ble_rscs;..\NRFLibraries\components\ble\ble_services\ble_rscs_c;..\NRFLibraries\components\ble\ble_services\ble_tps;..\NRFLibraries\components\ble\common;..\NRFLibraries\components\ble\nrf_ble_gatt;..\NRFLibraries\components\ble\nrf_ble_qwr;..\NRFLibraries\components\ble\peer_manager;..\NRFLibraries\components\boards;..\NRFLibraries\components\libraries\atomic;..\NRFLibraries\components\libraries\atomic_fifo;..\NRFLibraries\components\libraries\atomic_flags;..\NRFLibraries\components\libraries\balloc;..\NRFLibraries\components\libraries\bootloader\ble_dfu;..\NRFLibraries\components\libraries\bsp;..\NRFLibraries\components\libraries\button;..\NRFLibraries\components\libraries\cli;..\NRFLibraries\components\libraries\crc16;..\NRFLibraries\components\libraries\crc32;..\NRFLibraries\components\libraries\crypto;..\NRFLibraries\components\libraries\csense;..\NRFLibraries\components\libraries\csense_drv;..\NRFLibraries\components\libraries\delay;..\NRFLibraries\components\libraries\ecc;..\NRFLibraries\components\libraries\experimental_section_vars;..\NRFLibraries\components\libraries\experimental_task_manager;..\NRFLibraries\components\libraries\fds;..\NRFLibraries\components\libraries\fifo;..\NRFLibraries\components\libraries\fstorage;..\NRFLibraries\components\libraries\gfx;..\NRFLibraries\components\libraries\gpiote;..\NRFLibraries\components\libraries\hardfault;..\NRFLibraries\components\libraries\hci;..\NRFLibraries\components\libraries\led_softblink;..\NRFLibraries\components\libraries\log;..\NRFLibraries\components\libraries\log\src;..\NRFLibraries\components\libraries\low_power_pwm;..\NRFLibraries\components\libraries\mem_manager;..\NRFLibraries\components\libraries\memobj;..\NRFLibraries\components\libraries\mpu;..\NRFLibraries\components\libraries\mutex;..\NRFLibraries\components\libraries\pwm;..\NRFLibraries\components\libraries\pwr_mgmt;..\NRFLibraries\components\libraries\queue;..\NRFLibraries\components\libraries\ringbuf;..\NRFLibraries\components\libraries\scheduler;..\NRFLibraries\components\libraries\sdcard;..\NRFLibraries\components\libraries\sensorsim;..\NRFLibraries\components\libraries\slip;..\NRFLibraries\components\libraries\sortlist;..\NRFLibraries\components\libraries\spi_mngr;..\NRFLibraries\components\libraries\stack_guard;..\NRFLibraries\components\libraries\strerror;..\NRFLibraries\components\libraries\svc;..\NRFLibraries\components\libraries\timer;..\NRFLibraries\components\libraries\twi_mngr;..\NRFLibraries\components\libraries\twi_sensor;..\NRFLibraries\components\libraries\uart;..\NRFLibraries\components\libraries\util;..\NRFLibraries\components\softdevice\s132\headers;..\NRFLibraries\components\softdevice\s132\headers\nrf52;..\NRFLibraries\external\fprintf;..\NRFLibraries\external\segger_rtt;..\NRFLibraries\external\utf_converter;..\NRFLibraries\integration\nrfx;..\NRFLibraries\integration\nrfx\legacy;..\NRFLibraries\modules\nrfx;..\NRFLibraries\modules\nrfx\drivers\include;..\NRFLibraries\modules\nrfx\drivers\src;..\NRFLibraries\modules\nrfx\hal;..\NRFLibraries\config\nrf52832\config;..\NRFLibraries\components\softdevice\common;..\User\UART;..\User\SPI;..\Decadriver;..\Decadriver\platform;..\User\UWB;..\User\I2C;..\User\OLED;..\Ble_platform\Inc;..\User\TIMER;..\User\MODBUS;..\User\FLASH;..\Rtls;..\Rtls\HDS-TWR+;..\Rtls\DS-TWR+;..\Rtls\Algorithm;..\Rtls\MathLib\Inc;..\User\AT;..\Decadriver\Inc;..\Rtls\UWB_apps
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002c00 size 0xd400
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../User/: main.c port.c common_config.c
    ../NRFLibraries/config/nrf52832/config/: sdk_config.h
  group Hardware
    ../User/SPI/: bsp_spi.c
    ../User/OLED/: oled.c
    ../User/TIMER/: bsp_timer.c
    ../User/FLASH/: bsp_flash.c
    ../User/UART/: bsp_uart.c
    ../User/UWB/: dw3000.c
  group Commu
    ../User/MODBUS/: modbus.c
    ../User/AT/: AT.c
  group Ble_platform
    ../Ble_platform/src/: ble_app.c
  group nRF_BLE
    ../NRFLibraries/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../NRFLibraries/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../NRFLibraries/components/ble/ble_advertising/: ble_advertising.c
    ../NRFLibraries/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../NRFLibraries/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../NRFLibraries/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
  group nRF_BLE_Services
    ../NRFLibraries/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drives
    ../NRFLibraries/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c nrf_drv_uart.c
    ../NRFLibraries/modules/nrfx/soc/: nrfx_atomic.c
    ../NRFLibraries/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_spi.c nrfx_spim.c nrfx_uart.c nrfx_uarte.c nrfx_timer.c
    ../NRFLibraries/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../NRFLibraries/components/libraries/button/: app_button.c
    ../NRFLibraries/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../NRFLibraries/components/libraries/fifo/: app_fifo.c
    ../NRFLibraries/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../NRFLibraries/components/libraries/scheduler/: app_scheduler.c
    ../NRFLibraries/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../NRFLibraries/components/libraries/crc16/: crc16.c
    ../NRFLibraries/components/libraries/fds/: fds.c
    ../NRFLibraries/components/libraries/hardfault/: hardfault_implementation.c
    ../NRFLibraries/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../NRFLibraries/components/libraries/atomic_flags/: nrf_atflags.c
    ../NRFLibraries/components/libraries/atomic/: nrf_atomic.c
    ../NRFLibraries/components/libraries/balloc/: nrf_balloc.c
    ../NRFLibraries/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../NRFLibraries/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../NRFLibraries/components/libraries/memobj/: nrf_memobj.c
    ../NRFLibraries/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../NRFLibraries/components/libraries/ringbuf/: nrf_ringbuf.c
    ../NRFLibraries/components/libraries/sortlist/: nrf_sortlist.c
    ../NRFLibraries/components/libraries/strerror/: nrf_strerror.c
    ../NRFLibraries/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../NRFLibraries/components/libraries/sensorsim/: sensorsim.c
    ../NRFLibraries/components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../NRFLibraries/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../NRFLibraries/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nRF_SoftDevice
    ../NRFLibraries/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group UTF8/UTF16 converter
    ../NRFLibraries/external/utf_converter/: utf.c
  group Decawave
    ../Decadriver/platform/: deca_mutex.c deca_sleep.c deca_spi.c deca_device.c
  group DS-TWR+
    ../Rtls/DS-TWR+/: DS-TWR.c DS-TWR_Tag.c DS-TWR_SubAnchor.c DS-TWR_MainAnchor.c
  group HDS-TWR+
    ../Rtls/HDS-TWR+/: HDS-TWR.c HDS-TWR_Tag.c HDS-TWR_MainAnchor.c HDS-TWR_SubAnchor.c
  group Rtls
    ../Rtls/: TWR.c
    ../Rtls/Algorithm/: Filter.c loc.c Array.c
    ../Rtls/MathLib/: arm_cortexM4lf_math.lib
  group UWB apps
    ../Rtls/UWB_apps/: App_cir.c App_Range.c App_remote_cfg.c
target flash_s132_nrf52_7.2.0_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s132_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\User;..\NRFLibraries\components;..\NRFLibraries\components\ble\ble_advertising;..\NRFLibraries\components\ble\ble_dtm;..\NRFLibraries\components\ble\ble_racp;..\NRFLibraries\components\ble\ble_services\ble_ancs_c;..\NRFLibraries\components\ble\ble_services\ble_ans_c;..\NRFLibraries\components\ble\ble_services\ble_bas;..\NRFLibraries\components\ble\ble_services\ble_bas_c;..\NRFLibraries\components\ble\ble_services\ble_bps;..\NRFLibraries\components\ble\ble_services\ble_cscs;..\NRFLibraries\components\ble\ble_services\ble_cts_c;..\NRFLibraries\components\ble\ble_services\ble_dfu;..\NRFLibraries\components\ble\ble_services\ble_dis;..\NRFLibraries\components\ble\ble_services\ble_gls;..\NRFLibraries\components\ble\ble_services\ble_hids;..\NRFLibraries\components\ble\ble_services\ble_hrs;..\NRFLibraries\components\ble\ble_services\ble_hrs_c;..\NRFLibraries\components\ble\ble_services\ble_hts;..\NRFLibraries\components\ble\ble_services\ble_ias;..\NRFLibraries\components\ble\ble_services\ble_ias_c;..\NRFLibraries\components\ble\ble_services\ble_lbs;..\NRFLibraries\components\ble\ble_services\ble_lbs_c;..\NRFLibraries\components\ble\ble_services\ble_lls;..\NRFLibraries\components\ble\ble_services\ble_nus;..\NRFLibraries\components\ble\ble_services\ble_nus_c;..\NRFLibraries\components\ble\ble_services\ble_rscs;..\NRFLibraries\components\ble\ble_services\ble_rscs_c;..\NRFLibraries\components\ble\ble_services\ble_tps;..\NRFLibraries\components\ble\common;..\NRFLibraries\components\ble\nrf_ble_gatt;..\NRFLibraries\components\ble\nrf_ble_qwr;..\NRFLibraries\components\ble\peer_manager;..\NRFLibraries\components\boards;..\NRFLibraries\components\libraries\atomic;..\NRFLibraries\components\libraries\atomic_fifo;..\NRFLibraries\components\libraries\atomic_flags;..\NRFLibraries\components\libraries\balloc;..\NRFLibraries\components\libraries\bootloader\ble_dfu;..\NRFLibraries\components\libraries\bsp;..\NRFLibraries\components\libraries\button;..\NRFLibraries\components\libraries\cli;..\NRFLibraries\components\libraries\crc16;..\NRFLibraries\components\libraries\crc32;..\NRFLibraries\components\libraries\crypto;..\NRFLibraries\components\libraries\csense;..\NRFLibraries\components\libraries\csense_drv;..\NRFLibraries\components\libraries\delay;..\NRFLibraries\components\libraries\ecc;..\NRFLibraries\components\libraries\experimental_section_vars;..\NRFLibraries\components\libraries\experimental_task_manager;..\NRFLibraries\components\libraries\fds;..\NRFLibraries\components\libraries\fstorage;..\NRFLibraries\components\libraries\gfx;..\NRFLibraries\components\libraries\gpiote;..\NRFLibraries\components\libraries\hardfault;..\NRFLibraries\components\libraries\hci;..\NRFLibraries\components\libraries\led_softblink;..\NRFLibraries\components\libraries\log;..\NRFLibraries\components\libraries\log\src;..\NRFLibraries\components\libraries\low_power_pwm;..\NRFLibraries\components\libraries\mem_manager;..\NRFLibraries\components\libraries\memobj;..\NRFLibraries\components\libraries\mpu;..\NRFLibraries\components\libraries\mutex;..\NRFLibraries\components\libraries\pwm;..\NRFLibraries\components\libraries\pwr_mgmt;..\NRFLibraries\components\libraries\queue;..\NRFLibraries\components\libraries\ringbuf;..\NRFLibraries\components\libraries\scheduler;..\NRFLibraries\components\libraries\sdcard;..\NRFLibraries\components\libraries\sensorsim;..\NRFLibraries\components\libraries\slip;..\NRFLibraries\components\libraries\sortlist;..\NRFLibraries\components\libraries\spi_mngr;..\NRFLibraries\components\libraries\stack_guard;..\NRFLibraries\components\libraries\strerror;..\NRFLibraries\components\libraries\svc;..\NRFLibraries\components\libraries\timer;..\NRFLibraries\components\libraries\twi_mngr;..\NRFLibraries\components\libraries\twi_sensor;..\NRFLibraries\components\libraries\util;..\NRFLibraries\components\softdevice\s132\headers;..\NRFLibraries\components\softdevice\s132\headers\nrf52;..\NRFLibraries\external\fprintf;..\NRFLibraries\external\segger_rtt;..\NRFLibraries\external\utf_converter;..\NRFLibraries\integration\nrfx;..\NRFLibraries\integration\nrfx\legacy;..\NRFLibraries\modules\nrfx;..\NRFLibraries\modules\nrfx\drivers\include;..\NRFLibraries\modules\nrfx\hal;..\NRFLibraries\config\nrf52832\config;..\NRFLibraries\components\softdevice\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
software components: CMSIS:CORE 5.4.0, Device:Startup 8.44.1, Device:StartupConfig 8.44.1
